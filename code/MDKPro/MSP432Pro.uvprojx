# Keil uVision project MSP432Pro.uvprojx, settings and files
target MSP432 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSP432Pro
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__,TARGET_IS_MSP432P4XX,__TARGET_FPU_VFP
  c include: ..\Main;..\SL_RTE\RTE_APP;..\SL_RTE\RTE_Board\General_MSP432;..\SL_RTE\RTE_Config;..\MSP432P4xx_DriverLib;..\Board_BSP;..\Thread_APP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Main
    ../Main/: main.c
  group DriverLib
    ../MSP432P4xx_DriverLib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group RTE_APP
    ../SL_RTE/RTE_APP/: RTE_BGet.c RTE_Core.c RTE_KVDB.c RTE_List.c RTE_RetargetIO.c RTE_RingQuene.c RTE_RoundRobin.c RTE_Shell.c RTE_StateMachine.c RTE_Stdio.c RTE_Stdlib.c RTE_Vec.c
  group RTE_BSP
    ../SL_RTE/RTE_Board/General_MSP432/: BSP_Led.c BSP_Systick.c
  group RTE_Board
    ../Board_BSP/: Board_Usart.c
  group RTE_Config
    ../SL_RTE/RTE_Config/: RTE_Config.h
  group APP_Thread
    ../Thread_APP/: Thread_System.c Thread_Datasensor.c Thread_Stabilizer.c
  group Board_BSP
    ../Board_BSP/: Pwm_in.c Pwm_out.c Board_filter.c Telecontrol.c Board_SPI.C Board_MPU.C
  group Data_Calculate
    ../Board_BSP/: Data_IMU.c Data_Sensor.c Control.c configParam.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup 3.2.2
